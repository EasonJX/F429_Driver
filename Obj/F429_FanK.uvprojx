# Keil uVision project F429_FanK.uvprojx, settings and files
target Fanke (ARM-ADS)
  device: STM32F429BITx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.12.0
  cpu: IROM(0x08000000,0x200000) IRAM(0x20000000,0x30000) IRAM2(0x10000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: F429_FanK
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F429xx,ARM_MATH_CM4,__CC_ARM,ARM_MATH_MATRIX_CHECK,ARM_MATH_ROUNDING
  c misc: --C99
  c include: ..\Core;..\Lib\Inc;..\FreeRTOS\include;..\User\Inc;..\User;..\FreeRTOS\portable;..\Fatfs;..\STemWin\inc;..\STemWin\Config;..\STM32_USB_Device_Library\Core\Inc;..\STM32_USB_Device_Library\Class\MSC\Inc;..\GUI_Demo;..\lwip\system\OS;..\lwip\system;..\NetDemo;..\lwip\system\arch;..\lwip\src\apps\httpd;..\lwip\src\include\lwip\apps;..\lwip\src\include;..\NetDemo;..\App;..\emWinFont;..\PNG
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x30000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User
    ../User/Src/: fmc.c gpio.c ltdc.c main.c sdio.c spi.c stm32f4xx_hal_msp.c stm32f4xx_it.c system_stm32f4xx.c usart.c dma2d.c bsp_driver_sd.c fatfs.c spi_flash.c crc.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c dma.c lwip.c tim.c
  group CMSIS
    ../CMSIS/Lib/ARM/: arm_cortexM4lf_math.lib
  group Fatfs
    ../Fatfs/: diskio.c ff.c ff_gen_drv.c sd_diskio.c user_diskio.c
    ../Fatfs/option/: cc936.c syscall.c
  group Lib
    ../Lib/Src/: stm32f4xx_hal.c stm32f4xx_hal_adc.c stm32f4xx_hal_adc_ex.c stm32f4xx_hal_can.c stm32f4xx_hal_cec.c stm32f4xx_hal_cortex.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_dac.c stm32f4xx_hal_dac_ex.c stm32f4xx_hal_dcmi.c stm32f4xx_hal_dcmi_ex.c stm32f4xx_hal_dfsdm.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_dsi.c stm32f4xx_hal_eth.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_fmpi2c.c stm32f4xx_hal_fmpi2c_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_hash.c stm32f4xx_hal_hash_ex.c stm32f4xx_hal_hcd.c stm32f4xx_hal_i2c.c stm32f4xx_hal_i2c_ex.c stm32f4xx_hal_i2s.c stm32f4xx_hal_i2s_ex.c stm32f4xx_hal_irda.c stm32f4xx_hal_iwdg.c stm32f4xx_hal_lptim.c stm32f4xx_hal_ltdc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_hal_mmc.c stm32f4xx_hal_nand.c stm32f4xx_hal_nor.c stm32f4xx_hal_pccard.c stm32f4xx_hal_pcd.c stm32f4xx_hal_pcd_ex.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_qspi.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_rng.c stm32f4xx_hal_rtc.c stm32f4xx_hal_rtc_ex.c stm32f4xx_hal_sai.c stm32f4xx_hal_sai_ex.c stm32f4xx_hal_sd.c stm32f4xx_hal_sdram.c stm32f4xx_hal_smartcard.c stm32f4xx_hal_spdifrx.c stm32f4xx_hal_spi.c stm32f4xx_hal_sram.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c stm32f4xx_hal_usart.c stm32f4xx_hal_wwdg.c stm32f4xx_ll_adc.c stm32f4xx_ll_crc.c stm32f4xx_ll_dac.c stm32f4xx_ll_dma.c stm32f4xx_ll_dma2d.c stm32f4xx_ll_exti.c stm32f4xx_ll_fmc.c stm32f4xx_ll_fsmc.c stm32f4xx_ll_gpio.c stm32f4xx_ll_i2c.c stm32f4xx_ll_lptim.c stm32f4xx_ll_pwr.c stm32f4xx_ll_rcc.c stm32f4xx_ll_rng.c stm32f4xx_ll_rtc.c stm32f4xx_ll_sdmmc.c stm32f4xx_ll_spi.c stm32f4xx_ll_tim.c stm32f4xx_ll_usart.c stm32f4xx_ll_usb.c stm32f4xx_ll_utils.c
  group Core
    ../Core/: startup_stm32f429xx.s
  group FreeRTOS
    ../FreeRTOS/: croutine.c event_groups.c list.c queue.c tasks.c timers.c
    ../FreeRTOS/portable/: heap_4.c port.c
  group STemWin
    ../STemWin/Config/: GUIConf.c LCDConf_Lin_Template.c
    ../STemWin/OS/: GUI_X_FreeRTOS.c
    ../STemWin/Lib/: STemWin540_CM4_OS_Keil_ot_ARGB.lib
  group Usb
    ../STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
  group GUI_Demo
    ../GUI_Demo/: GUIDEMO.c GUIDEMO_AntialiasedText.c GUIDEMO_Automotive.c GUIDEMO_BarGraph.c GUIDEMO_Bitmap.c GUIDEMO_ColorBar.c GUIDEMO_Conf.c GUIDEMO_Cursor.c GUIDEMO_Fading.c GUIDEMO_Graph.c GUIDEMO_IconView.c GUIDEMO_ImageFlow.c GUIDEMO_Intro.c GUIDEMO_Listview.c GUIDEMO_RadialMenu.c GUIDEMO_Resource.c GUIDEMO_Skinning.c GUIDEMO_Speed.c GUIDEMO_Speedometer.c GUIDEMO_Start.c GUIDEMO_TransparentDialog.c GUIDEMO_Treeview.c GUIDEMO_VScreen.c GUIDEMO_WashingMachine.c GUIDEMO_ZoomAndRotate.c
  group GUI_User
    ../GUI_User/: apple.c bar.c clock.c ETI_logo.c game.c git.c gitlogo.c keil.c mail.c Palette.c QQ.c QQlogo.c QQVIP.c return.c target.c Text.c Theme.c wechat.c Win_main.c Win1.c Win3.c Win4.c Win6.c Win7.c winheader.c
  group GUI_ETI
    ../ETI_Test/: apple.c bar.c clock.c Curve_Fitting.c ETI_logo.c game.c git.c gitlogo.c keil.c mail.c Palette.c QQ.c QQlogo.c QQVIP.c return.c target.c Text.c Theme.c wechat.c Win1.c Win3.c Win4.c Win6.c winheader.c wz.c mygui.h
  group GUI_RGBLink
    ../GUI_RGBLink/: apple.c bar.c game.c git.c Hlogo.c keil.c logo.c mail.c QQ.c return.c wechat.c winheader.c WinMain.c
  group Lwip
    ../lwip/src/api/: api_lib.c api_msg.c err.c netbuf.c netdb.c netifapi.c sockets.c tcpip.c
    ../lwip/src/core/: def.c dns.c inet_chksum.c init.c ip.c mem.c memp.c netif.c pbuf.c raw.c stats.c sys.c tcp.c tcp_in.c tcp_out.c timeouts.c udp.c
    ../lwip/src/core/ipv4/: autoip.c dhcp.c etharp.c icmp.c igmp.c ip4.c ip4_addr.c ip4_frag.c
    ../lwip/src/netif/: ethernet.c lowpan6.c slipif.c
  group Net
    ../lwip/system/OS/: ethernetif.c sys_arch.c
    ../lwip/system/arch/: lwipopts.h
  group Net_Demo
    ../NetDemo/: httpd_cgi_ssi.c httpserver-netconn.c ntp_client.c smtp.c tcpecho.c udpecho.c vnc_thread.c fs_custom.c tcp_client.c httpd_post.c multipart_parser.c
    ../lwip/src/apps/httpd/: httpd.c fs.c
    ../lwip/src/apps/netbiosns/: netbiosns.c
    ../lwip/src/apps/tftp/: tftp_server.c
    ../lwip/src/apps/sntp/: sntp.c
  group App
    ../App/: bmp.c tftp_file.c adc.c display.c touch.c app_task.c GetData.c
  group Font
    ../emWinFont/: siffont.c xbffont.c Font_Test.c Demo_String.c
